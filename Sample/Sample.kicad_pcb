# Repository 23yzhang/Evan-PCB-ISP

## KiCad design Corne Integrated Microchip/Corne Integrated Microchip.kicad_pcb

Parts:
C1, C2, C3, C4: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C5, C6: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7, C8, C9, C10, C12, C13, C14, C15: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C11, C16: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1, F2: 500m; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1, J2: MJ-4PP-9; MJ-4PP-9_1side
OL1, OL2: OLED
R1, R2, R3, R4: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R6, R9, R10: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7, R8, R11, R12: 5.1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1, SW2: SW_Push; ResetSW_1side
U1, U2: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
U3, U4: PRTR5V0U2X; SOT143B
USB1, USB2: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-HandSoldering
Y1, Y2: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C7.1, C8.1, C9.1, C10.1, C11.1, F2.1, R1.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
+5VA: C12.1, C13.1, C14.1, C15.1, C16.1, F1.1, R2.1, U2.2 (UVCC), U2.7 (VBUS), U2.14 (VCC), U2.24 (AVCC), U2.34 (VCC), U2.44 (AVCC)
COL0: U1.41 (PF0); also elsewhere on the board
COL1: U1.40 (PF1); also elsewhere on the board
COL2: U1.39 (PF4); also elsewhere on the board
COL3: U1.38 (PF5); also elsewhere on the board
COL4: U1.37 (PF6); also elsewhere on the board
COL5: U1.36 (PF7); also elsewhere on the board
COL6: U2.30 (PB6); also elsewhere on the board
COL7: U2.29 (PB5); also elsewhere on the board
COL8: U2.28 (PB4); also elsewhere on the board
COL9: U2.27 (PD7); also elsewhere on the board
COL10: U2.26 (PD6); also elsewhere on the board
COL11: U2.25 (PD4); also elsewhere on the board
D+: R10.1, U1.4 (D+)
D-: R9.1, U1.3 (D-)
DATA: J1.B, U1.10 (PB2)
DATA_R: J2.B, U2.10 (PB2)
DN: R9.2, U4.3 (IO2), USB2.5 (DN2), USB2.7 (DN1)
DP: R10.2, U4.2 (IO1), USB2.6 (DP1), USB2.8 (DP2)
GND: C1.2, C3.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.C, OL1.4 (GND), R3.1, R11.1, R12.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), U4.1 (GND), USB2.1 (GND), USB2.12 (GND), USB2.13 (SHIELD), Y1.2, Y1.4
GNDA: C2.2, C4.2, C6.2, C12.2, C13.2, C14.2, C15.2, C16.2, J2.C, OL2.4 (GND), R4.1, R7.1, R8.1, SW2.1, U2.5 (UGND), U2.15 (GND), U2.23 (GND), U2.35 (GND), U2.43 (GND), U3.1 (GND), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHIELD), Y2.2, Y2.4
unnamed: C1.1, U1.17 (XTAL1), Y1.1
unnamed: C2.1, U2.17 (XTAL1), Y2.1
unnamed: C3.1, U1.16 (XTAL2), Y1.3
unnamed: C4.1, U2.16 (XTAL2), Y2.3
unnamed: C5.1, U1.6 (UCAP)
unnamed: C6.1, U2.6 (UCAP)
unnamed: R1.2, SW1.2, U1.13 (~RESET)
unnamed: R2.2, SW2.2, U2.13 (~RESET)
unnamed: R3.2, U1.33 (~HWB~/PE2)
unnamed: R4.2, U2.33 (~HWB~/PE2)
unnamed: R7.2, USB1.10 (CC2)
unnamed: R8.2, USB1.4 (CC1)
unnamed: R11.2, USB2.10 (CC2)
unnamed: R12.2, USB2.4 (CC1)
ROW0: U1.18 (PD0); also elsewhere on the board
ROW1: U1.19 (PD1); also elsewhere on the board
ROW5: U2.40 (PF1); also elsewhere on the board
ROW6: U2.39 (PF4); also elsewhere on the board
ROW7: U2.38 (PF5); also elsewhere on the board
SCL: OL1.2 (SCL), U1.8 (PB0)
SCL_R: OL2.2 (SCL), U2.8 (PB0)
SDA: OL1.1 (SDA), U1.9 (PB1)
SDA_R: OL2.1 (SDA), U2.9 (PB1)
VCC: F2.2, J1.D, OL1.3 (VCC), U4.4 (VCC), USB2.2 (VBUS), USB2.11 (VBUS)
VDD: F1.2, J2.D, OL2.3 (VCC), U3.4 (VCC), USB1.2 (VBUS), USB1.11 (VBUS)
rD+: R6.1, U2.4 (D+)
rD-: R5.1, U2.3 (D-)
rDN: R5.2, U3.3 (IO2), USB1.5 (DN2), USB1.7 (DN1)
rDP: R6.2, U3.2 (IO1), USB1.6 (DP1), USB1.8 (DP2)

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42: 0805
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42: MX-NoLED

Connections:
COL0: MX1.1 (COL), MX7.1 (COL), MX13.1 (COL); also elsewhere on the board
COL1: MX2.1 (COL), MX8.1 (COL), MX14.1 (COL); also elsewhere on the board
COL2: MX3.1 (COL), MX9.1 (COL), MX15.1 (COL); also elsewhere on the board
COL3: MX4.1 (COL), MX10.1 (COL), MX16.1 (COL), MX19.1 (COL); also elsewhere on the board
COL4: MX5.1 (COL), MX11.1 (COL), MX17.1 (COL), MX20.1 (COL); also elsewhere on the board
COL5: MX6.1 (COL), MX12.1 (COL), MX18.1 (COL), MX21.1 (COL); also elsewhere on the board
COL6: MX22.1 (COL), MX28.1 (COL), MX34.1 (COL), MX40.1 (COL); also elsewhere on the board
COL7: MX23.1 (COL), MX29.1 (COL), MX35.1 (COL), MX41.1 (COL); also elsewhere on the board
COL8: MX24.1 (COL), MX30.1 (COL), MX36.1 (COL), MX42.1 (COL); also elsewhere on the board
COL9: MX25.1 (COL), MX31.1 (COL), MX37.1 (COL); also elsewhere on the board
COL10: MX26.1 (COL), MX32.1 (COL), MX38.1 (COL); also elsewhere on the board
COL11: MX27.1 (COL), MX33.1 (COL), MX39.1 (COL); also elsewhere on the board
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX26.2 (ROW)
unnamed: D27.2 (A), MX27.2 (ROW)
unnamed: D28.2 (A), MX28.2 (ROW)
unnamed: D29.2 (A), MX29.2 (ROW)
unnamed: D30.2 (A), MX30.2 (ROW)
unnamed: D31.2 (A), MX31.2 (ROW)
unnamed: D32.2 (A), MX32.2 (ROW)
unnamed: D33.2 (A), MX33.2 (ROW)
unnamed: D34.2 (A), MX34.2 (ROW)
unnamed: D35.2 (A), MX35.2 (ROW)
unnamed: D36.2 (A), MX36.2 (ROW)
unnamed: D37.2 (A), MX37.2 (ROW)
unnamed: D38.2 (A), MX38.2 (ROW)
unnamed: D39.2 (A), MX39.2 (ROW)
unnamed: D40.2 (A), MX40.2 (ROW)
unnamed: D41.2 (A), MX41.2 (ROW)
unnamed: D42.2 (A), MX42.2 (ROW)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K); also elsewhere on the board
ROW1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K); also elsewhere on the board
ROW5: D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K); also elsewhere on the board
ROW6: D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K); also elsewhere on the board
ROW7: D40.1 (K), D41.1 (K), D42.1 (K); also elsewhere on the board

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
Board: 2 copper layers, 282.6 x 94.5 mm, 128 parts (42 on the bottom side), 96 nets.

## KiCad design Evan-PCB-ISP.kicad_pcb

Parts:
C1, C2, C3: 0.1uF; C_0805_2012Metric
C4, C5: 22pF; C_0805_2012Metric
C6: 10uF; C_0805_2012Metric
C7: 1uF; C_0805_2012Metric
D1, D2, D3, D4: SOD-123; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
MX1, MX2, MX3, MX4: MX-NoLED; MX-1U-NoLED
R1, R2: 22; R_0805_2012Metric
R3, R4: 10k; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
USB1: Molex-0548190589
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, C3.1, C6.1, F1.1, R3.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL0: MX1.1 (COL), MX2.1 (COL), U1.29 (PB5)
COL1: MX3.1 (COL), MX4.1 (COL), U1.28 (PB4)
D+: R2.2, USB1.3
D-: R1.2, USB1.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R4.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), USB1.1, Y1.2, Y1.4
unnamed: C4.1, U1.17 (XTAL1), Y1.1
unnamed: C5.1, U1.16 (XTAL2), Y1.3
unnamed: C7.1, U1.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: R1.1, U1.3 (D-)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.2, SW1.2, U1.13 (~RESET)
unnamed: R4.2, U1.33 (~HWB~/PE2)
ROW0: D1.1 (K), D3.1 (K), U1.27 (PD7)
ROW1: D2.1 (K), D4.1 (K), U1.30 (PB6)
VCC: F1.2, USB1.5

Board: 2 copper layers, 76.2 x 38.1 mm, 24 parts (20 on the bottom side), 20 nets.

## Commit log

2023-04-27 Initialize project
2023-04-27 Add submodules
2023-04-27 Add footprint libraries
2023-04-27 MCU Schematic
    Completed MCU zone
2023-04-27 Rest of schematic & assigning footprints
2023-04-28 Preparing, routing, and matrix pinout
    Ordered the pcb layout, routed the trace, and selected the matrix pinout.
2023-04-28 Ground fills, decoration, no debugging yet
2023-04-29 regular save
2023-04-29 Created Gerber Files
2023-04-29 Finished tutorial, started rev 1
2023-04-29 Add nice nano submodule
2023-04-29 Schematic, layout, and footprint assignment
2023-04-29 rev 1 finished
    Completed rev 1:
    - layout
    - routing all trace
    - ground fill
    - silk screen art :)
2023-04-29 Gerber files
2023-05-01 Exported PCB .step
2023-05-01 Create plate.dxf
    NOTE: the pcb file has the stabilizer holes in reverse, meaning the plate needs the longer end of the stabilizer cutout in reverse as well. In KLE, rotate all keys with stabilizers by 180 degrees.
    This will be fixed in rev 2.
2023-05-01 Add promicro submodule
2023-05-01 add additional footprint & libraries
2023-05-01 Schematic & assign footprint
2023-05-01 Started pcb
2023-05-05 big update
    whatever
2023-05-05 Added partial pcb routing
2023-05-08 Add type c library
2023-05-08 Schematic
2023-05-08 Assigned Footprint
2023-05-09 Started routing
2023-05-15 continued routing
2023-05-16 Finished routing
2023-05-16 Optimizing optimizing optimizing
2023-05-18 Added refernece pcbs
2023-05-19 Organization
    I put all the old projects into a separate folder
2023-05-20 Final? rev 1.0
    Tidied everything up, should be good to go now :)
2023-05-20 Added breakaway tabs
    Added breakaway tabs to connect both sides of the board.
2023-05-20 Forgot to refill ground pour
2023-05-20 Generate drill files
2023-05-25 Renamed project & added case design
    Changed name to honk40, I feel that this project is different enough to warrant the name change.
    Case created in Fusion 360
2023-05-26 added stencil svg
